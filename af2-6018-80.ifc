Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: af2-6018-80.ifc
Time: 2022-11-10T17:31:11
Organization: SST
Written by: Processor version 21.0.0.1
Made in: SSTIFC
Authorization: SST

# IfcProject, Default Project
Description: Description of Default Project; LongName: Project Status; Phase: Project Status

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Storey
In: Default Building
Description: Description of Default Building Storey
